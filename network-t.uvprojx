# Keil uVision project network-t.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: Keil.Kinetis_SDK_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: network-t
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Source Group 1
    ./Adafruit_LED_Backpack-master 2/: Adafruit_LEDBackpack.cpp Adafruit_LEDBackpack.h
    ./Adafruit_LED_Backpack-master 2/matrix16x8/: matrix16x8.ino
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX5 5.0.0, CMSIS:RTOS2:Keil RTX5 5.0.0, Network:CORE 6.5.0, Network:Interface:ETH 6.5.0, Network:Service:DNS Client 6.5.0, Network:Socket:UDP 6.5.0, CMSIS Driver:Ethernet MAC 1.2, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.00, Device:KSDK Configuration:FRDM-K64F 1.2.0, Device:KSDK Driver:GPIO 1.2.0, Device:KSDK Driver:RTC 1.2.0, Device:KSDK HAL:ENET 1.2.0, Device:KSDK HAL:GPIO 1.2.0, Device:KSDK HAL:LPTMR 1.2.0, Device:KSDK HAL:MCG 1.2.0, Device:KSDK HAL:OSC 1.2.0, Device:KSDK HAL:PORT 1.2.0, Device:KSDK HAL:RTC 1.2.0, Device:KSDK HAL:SIM 1.2.0, Device:KSDK HAL:UART 1.2.0, Device:KSDK OSA:OSA 1.2.0, Device:KSDK System:Clock 1.2.0, Device:KSDK System:Interrupt 1.2.0, Device:KSDK Utility:Debug Console 1.2.0, Device:KSDK Utility:Misc 1.2.0, Device:Startup 2.8
